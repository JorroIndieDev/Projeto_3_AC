# Keil uVision project Trabalho_3_c_ARM_ASM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Trabalho_3_c_ARM_ASM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Parking_lot_C.c
